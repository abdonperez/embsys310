<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\PWM_LED1_AGP.ewp</path>
  </project>
  <batchBuild />
</workspace>
