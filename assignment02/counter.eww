<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\counter_proj.ewp</path>
    </project>
    <batchBuild />
</workspace>
